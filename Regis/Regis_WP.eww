<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Clock\Clock.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Interrupt\Interrupt.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SPI\SPI.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Uart\Uart.ewp</path>
    </project>
    <batchBuild />
</workspace>
